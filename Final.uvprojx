# Keil uVision project Final.uvprojx, settings and files
target Final (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final
  c flags: Optim=2 v6Lang=1 v6LangP=5
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Code
    ./: Startup.s main.s portAconfig.s portBconfig.s portCconfig.s portDconfig.s portFconfig.s SysTickTimer_Setup.s specificAim1_LEDs.s specificAim2_buttons.s specificAim3_buzzer.s specificAim4_motor.s
software components: CMSIS:CORE 5.6.0
